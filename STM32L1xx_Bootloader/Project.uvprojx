# Keil uVision project Project.uvprojx, settings and files
target STM32L1xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Output\@L.bin !L
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX
  c include: .\User;.\FWlib\src;.\FWlib\inc;.\CMSIS;.\BSD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ./User/: main.c stm32l1xx_it.c IAP.c Modbus.c
  group BSD
    ./BSD/: gpio.c IEEPROM.c IFLASH.c uart.c
  group StdPeriph_Driver
    ./FWlib/src/: misc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ./User/: system_stm32l1xx.c
  group MDK-ARM
    ./CMSIS/startup/arm/: startup_stm32l1xx_md.s
